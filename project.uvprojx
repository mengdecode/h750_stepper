# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, STM32H750xx, USE_HAL_DRIVER, RT_USING_LIBC, __RTTHREAD__
  c include: applications\speed_loop;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;applications\stepper_drv;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\smp_call;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;packages\CMSIS-Core-latest\Include;rt-thread\components\net\utest;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\drivers;packages\stm32h7_hal_driver-latest\Inc\Legacy;rt-thread\components\drivers\include;rt-thread\include;rt-thread\components\libc\compilers\common\extension;board\CubeMX_Config\Inc;packages\stm32h7_hal_driver-latest\Inc;applications\stepper_drv;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\drivers\phy;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;packages\CmBacktrace-latest;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\poll;applications\open_loop;applications\position_loop;applications\stepper_drv;rt-thread\components\utilities\ulog;rt-thread\components\drivers\include;applications\stepper_drv;rt-thread\components\libc\posix\io\epoll;packages\stm32h7_cmsis_driver-latest\Include;board;libraries\HAL_Drivers;applications;rt-thread\components\libc\compilers\common\extension\fcntl\octal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pulse_encoder.c rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial_v2.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_pulse_encoder.c drv_pwm.c drv_spi.c drv_tim.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstring.c kerrno.c kstdio.c rt_vsscanf.c rt_vsnprintf_std.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group position_loop
    applications/position_loop/: test_positionloop.c position_loop.c
  group speed_loop
    applications/speed_loop/: speed_loop.c test_speedloop.c
  group stepper_common
    applications/stepper_drv/: stepper_encoder_driver.c stepper_pid_pos.c position_scale.c stepper_motor_driver.c
  group stepper_ol
    applications/open_loop/: test_openloop.c stepper_openloop.c
  group STM32H7-CMSIS
    packages/stm32h7_cmsis_driver-latest/Source/Templates/arm/: startup_stm32h750xx.s
    packages/stm32h7_cmsis_driver-latest/Source/Templates/: system_stm32h7xx.c
  group STM32H7-HAL
    packages/stm32h7_hal_driver-latest/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_crc.c stm32h7xx_hal_lptim.c stm32h7xx_hal_cryp.c stm32h7xx_hal_rng.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_qspi.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_usart.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_spi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
